# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c AT24C02.c I2C.c DS18B20.c OneWire.c Key.c Timer0.c Timer0.h DS1302.c DS1302.h public.h lcd12864.c lcd12864.h
